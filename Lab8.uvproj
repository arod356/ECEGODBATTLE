# Keil uVision project Lab8.uvproj, settings and files
target Lab8 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab8
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s LCD.s Print.s ADC.c Lab8.c ST7735.c dac.c Timer0.c Timer1.c Sound.c
    ../../../../Desktop/lab10-starter-master-8392400a7d36907eafc940a1036025b4a4e0e430/lab10-starter-master-8392400a7d36907eafc940a1036025b4a4e0e430/: random.s
  group Object code
    ./: texas.o
